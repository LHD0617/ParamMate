# Keil uVision project MakeLibProject.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MakeLibProject (library)
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\STM32F103_RTThread_Drive\ParamMate
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ../STM32F103_RTThread_Drive/ParamMate/: ParamMate.h PM_CommProt.c PM_CommProt.h PM_Image.c PM_Image.h PM_Param.c PM_Param.h PM_Waveform.c PM_Waveform.h PM_Window.c PM_Window.h
