# Keil uVision project STM32F103_RTThread_Drive.uvprojx, settings and files
target STM32F103_RTThread_Drive (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103_RTThread_Drive +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32F103xB
  c include: ../Core/Inc;../User/Inc;../Drivers/Inc;../RT-Thread;../RT-Thread/include;../RT-Thread/finsh;../RT-Thread/components/finsh;..\ParamMate
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Core
    ./: startup_stm32f103xb.s
    ../Core/Src/: system_stm32f1xx.c stm32f1xx_it.c IRQHandler.c
  group User
    ../User/Src/: main.c
  group Drivers
    ../Drivers/Src/: gpio.c uart.c nvic.c adc.c pit.c pwm.c exti.c
  group RT-Thread
    ../RT-Thread/components/device/: device.c
    ../RT-Thread/components/finsh/: cmd.c finsh_port.c msh.c shell.c
    ../RT-Thread/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
    ../RT-Thread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
    ../RT-Thread/bsp/: board.c
  group ParamMate
    ../ParamMate/: ParamMate.c ParamMate.h PM_CommProt.c PM_CommProt.h
software components: CMSIS:CORE 5.2.0
